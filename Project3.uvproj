# Keil uVision project Project3.uvproj, settings and files
target CMSIS-DAP -Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: Project3
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Startup
    ./src/: system_MKL25Z4.c startup_MKL25Z4.s
  group Source Files
    ./src/: main.c Leds.h Leds.c SysTick.c SysTick.h GpioDefs.h Settings.h StepperMotor.c StepperMotor.h MotorMode.c MotorMode.h Pit.h Pit.c
  group RTX Configuration
    ./src/: RTX_Config.c
target CMSIS-DAP -RAM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x1ffff000 size 0x2000
  memory RVCT9: RAM 0x20001000 size 0x3000
